DEPENDS:append:axelera-machine = " libtirpc"
