PACKAGECONFIG:append = " install-test-programs"
