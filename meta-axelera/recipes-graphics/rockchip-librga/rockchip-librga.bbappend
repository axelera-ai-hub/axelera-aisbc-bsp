SRC_URI:prepend:firefly-rk3588 = "git://gitlab.com/firefly-linux/external/linux-rga.git;protocol=https;nobranch=1;branch=rk3588/linux_yocto_release; "
SRC_URI:remove:firefly-rk3588 = "git://github.com/JeffyCN/mirrors.git;protocol=https;branch=linux-rga-multi;"
SRCREV:firefly-rk3588 = "bfeaf919fd9570efdd405ce7212bf784455f725f"

SRC_URI:prepend:itx-3588j = "git://gitlab.com/firefly-linux/external/linux-rga.git;protocol=https;nobranch=1;branch=rk3588/linux_yocto_release; "
SRC_URI:remove:itx-3588j = "git://github.com/JeffyCN/mirrors.git;protocol=https;branch=linux-rga-multi;"
SRCREV:itx-3588j = "bfeaf919fd9570efdd405ce7212bf784455f725f"

