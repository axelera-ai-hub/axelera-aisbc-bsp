VOLATILE_BINDS:append:axelera-machine = "\
    /data/overlay/home /home\n\
"
