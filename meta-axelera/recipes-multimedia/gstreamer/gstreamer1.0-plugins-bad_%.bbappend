PACKAGECONFIG:append:axelera-machine = " opencv"
