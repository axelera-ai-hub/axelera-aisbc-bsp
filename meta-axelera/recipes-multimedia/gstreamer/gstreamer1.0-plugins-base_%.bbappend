PACKAGECONFIG:append:axelera-machine = " alsa"
