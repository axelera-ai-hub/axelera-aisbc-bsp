SRC_URI:axelera-machine = "${REMOTE_REPOS_PREFIX}rockchip-mpp.git;protocol=${REMOTE_PROTOCOL};nobranch=1;branch=rk3588"
SRCREV:axelera-machine = "eff1e2ede31817c7d6fbe9c62421ab4955f962b7"
