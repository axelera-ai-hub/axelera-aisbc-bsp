COMPATIBLE_MACHINE = "(antelao-3588|itx-3588j)"
# rk3588 was not yet officially supported in optee v3.16.0,
# so use rk3399 instead.
OPTEEMACHINE = "rockchip-rk3399"
