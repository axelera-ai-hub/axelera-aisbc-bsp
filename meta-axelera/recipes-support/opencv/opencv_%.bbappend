PACKAGECONFIG:append:axelera-machine = " gstreamer opencl python3 dnn"
