FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-avbtool-Hardcode-dm-argument.patch"
