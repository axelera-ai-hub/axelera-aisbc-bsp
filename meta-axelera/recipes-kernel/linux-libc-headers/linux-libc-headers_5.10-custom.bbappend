# Copyright (C) 2021, Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

SRCREV = "a30d5a5e2455f04b855fdd8aacbf0ec832004202"

SRC_URI = " \
	git://gitlab.com/firefly-linux/kernel.git;protocol=https;nobranch=1;branch="rk3588/firefly"; \
"
